# Autodesk Inventor assembly: SP061512-1 DOOR
## iProperties
Created: 2012-06
Part Number: SP061512-1 DOOR
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator

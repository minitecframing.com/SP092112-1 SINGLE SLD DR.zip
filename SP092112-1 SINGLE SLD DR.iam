# Autodesk Inventor assembly: SP092112-1
## iProperties
Created: 2012-09
Part Number: SP092112-1
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
